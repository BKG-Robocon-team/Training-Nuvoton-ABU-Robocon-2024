# Keil uVision project DemoCodeGen.uvprojx, settings and files
target DemoCodeGen (6190000::V6.19::ARMCLANG)
  device: M258KE3AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.22
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: DemoCodeGen
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: __HXT=12000000ul __LXT=32768ul
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M251\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\SmartcardLib\Include;..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --map --first='startup_M251.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M251/Source/: system_M251.c
    ../../../../Library/Device/Nuvoton/M251/Source/ARM/: startup_M251.s
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c retarget.c sys.c uart.c tk.c acmp.c bpwm.c crc.c crypto.c dac.c eadc.c ebi.c fmc.c i2c.c lcd.c pdma.c pwm.c qspi.c rtc.c sc.c scuart.c spi.c timer.c timer_pwm.c usbd.c usci_i2c.c usci_spi.c usci_uart.c wdt.c wwdt.c
    ../../../../Library/TKLib/: TKLib_Calibration.lib TKLib_FreeRun.lib
    ../: wit_c_sdk.c
  group User
    ../: main.c clk_conf.c periph_conf.c pin_conf.c int_handler.c
